# Keil uVision project nexlink_f405_husb.uvprojx, settings and files
target nexlink_f405_husb (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: nexlink_f405_husb +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx,USE_USB_HS,ARM_MATH_CM4,ARM_MATH_CM4,__CC_ARM,__TARGET_FPU_VFP
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/NEX_LINK/Inc;../ThirdPart/chipmunk/include;../ThirdPart/easyui/include;../ThirdPart/chipmunk;../ThirdPart/easyui;../ThirdPart/mygui;../ThirdPart/mpu6050;../ThirdPart/bmp280;../ThirdPart/rx8900;../Middlewares/ST/ARM/DSP/Inc;../ThirdPart/beep
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ../Middlewares/ST/ARM/DSP/Inc/: arm_math.h
    ./: startup_stm32f405xx.s
  group Application/User/Core
    ../Core/Src/: lv_anim_light.c myiic.c main.c gpio.c adc.c crc.c dma.c i2s.c iwdg.c rng.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
    ../ThirdPart/stmflash/: stmflash.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Core/Src/: stm32f4xx_hal_timebase_tim.c
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_crc.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rng.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Application/User/USB_DEVICE/App
    ../Middlewares/ST/STM32_USB_Device_Library/Class/NEX_LINK/Src/: usbd_nex_link.c nexlink_app.c nexlink_tx.c nexlink_usb_if.c
    ../USB_DEVICE/App/: usbd_desc.c usbd_cdc_if.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c usbd_composite_builder.c
  group ThirdPart/easyui
    ../ThirdPart/easyui/src/: easy_key.c easy_ui.c easy_ui_user_app.c my_math.c zf_common_font.c zf_common_function.c nv3030b.c
  group ThirdPart/mygui
    ../ThirdPart/mygui/: animation.c fftaffect.c
  group ThirdPart/mpu6050
    ../ThirdPart/mpu6050/: inv_mpu.c inv_mpu_dmp_motion_driver.c mpu6050.c
  group ThirdPart/bmp280
    ../ThirdPart/bmp280/: bmp280.c
  group ThirdPart/rx8900
    ../ThirdPart/rx8900/: rx8900.c
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4lf_math.lib
  group ThirdPart/beep
    ../ThirdPart/beep/: beep.c
target nexlink_f405_husb_app (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: nexlink_f405_husb +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: addheader.bat "$P" "@L" "$L@L.bin"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F405xx,USER_VECT_TAB_ADDRESS,USE_USB_HS,VECT_TAB_OFFSET = 0x10000U,ARM_MATH_CM4,ARM_MATH_CM4,__CC_ARM,__TARGET_FPU_VFP,HUSB
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/NEX_LINK/Inc;..\ThirdPart\chipmunk\include;..\ThirdPart\chipmunk;..\ThirdPart\easyui\include;..\ThirdPart\easyui;..\ThirdPart\mygui;..\ThirdPart\mpu6050;..\ThirdPart\bmp280;..\ThirdPart\rx8900;..\Middlewares\ST\ARM\DSP\Inc;..\ThirdPart\beep;..\ThirdPart\stmflash
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.4.0
